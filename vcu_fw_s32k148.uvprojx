# Keil uVision project vcu_fw_s32k148.uvprojx, settings and files
target VCU (6140000::V6.14::ARMCLANG)
  device: S32K148UAxxxLQx NXP
  pack: Keil.S32_SDK_DFP.1.5.0
  cpu: IRAM(0x20000000,0x0001F000) IRAM2(0x1FFE0000,0x00020000) IROM(0x00000000,0x00180000) IROM2(0x10000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: vcu_fixture_fx +hex
  BeforeMake: .\build\pre_build.bat
  AfterMake: .\build\post_build.bat
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CPU_S32K148  __ARM_PCS_VFP  __FPU_PRESENT  __TARGET_FPU_VFP FEATURE_ENET_HAS_RX_CONFIG FEATURE_ENET_HAS_ACCELERATOR FEATURE_ENET_HAS_SLEEP_WAKEUP  FEATURE_ENET_RX_CONFIG_PAYLOAD_LEN_CHECK  FEATURE_ENET_RX_CONFIG_STRIP_CRC_FIELD  FEATURE_ENET_RX_CONFIG_FORWARD_PAUSE_FRAMES  FEATURE_ENET_RX_CONFIG_REMOVE_PADDING FEATURE_ENET_HAS_TX_CONFIG
  c misc: -Wpedantic -mthumb -mno-unaligned-access -Wno-extra-semi-stmt -Wno-dollar-in-identifier-extension -Wno-declaration-after-statement -mfloat-abi=hard -Wno-covered-switch-default -Wno-padded -Wno-switch-enum -Wno-cast-align -Wno-cast-qual  -Wno-reserved-id-macro -Wno-gnu-zero-variadic-macro-arguments -Wno-empty-translation-unit
  c include: .\boot;.\boot\inc;.\drivers\inc;.\firmware\inc;.\sec\inc;.\test\inc;.\util;.\util\inc;.\util\uzlib;.\util\uzlib\src;.\chipset\inc;.\chipset\src\adc;.\chipset\src\clock\S32K1xx;.\chipset\src\clock;.\chipset\src\cmp;.\chipset\src\crc;.\chipset\src\csec;.\chipset\src\edma;.\chipset\src\eim;.\chipset\src\erm;.\chipset\src\ewm;.\chipset\src\flash;.\chipset\src\flexcan;.\chipset\src\flexio;.\chipset\src\ftm;.\chipset\src\interrupt;.\chipset\src\lpi2c;.\chipset\src\lpit;.\chipset\src\lpspi;.\chipset\src\lptmr;.\chipset\src\lpuart;.\chipset\src\mpu;.\chipset\src\pdb;.\chipset\src\pins;.\chipset\src\power;.\chipset\src\power\S32K1xx;.\chipset\src\rtc;.\chipset\src\trgmux;.\chipset\src\wdog;.\cmsis;.\os\RTOS2\Include;.\os\RTOS2\RTX\Config;.\os\RTOS2\RTX\Include;.\os\RTOS2\RTX\Include1;.\os\RTOS2\RTX\Source;.\drivers\inc\eth;.\drivers\inc\eth\lld;.\os_validation\inc;.\os_validation\src\Config;.\net;.\net\api;.\net\core;.\net\core\ipv4;.\net\core\ipv6;.\net\include;.\net\include\arch;.\net\include\compat\stdc;.\net\include\compat;.\net\include\lwip;.\net\include\lwip\priv;.\net\include\lwip\prot;.\net\include\netif;.\net\include\netif\ppp;.\net\include\netif\ppp\polarssl;.\net\include\posix\sys;.\net\include\posix\sys;.\net\netif\ppp;.\net\netif;.\net\rte\config;.\net\rte\include;.\net\rte;.\drivers\src\icm20948;.\vcu_can_comm_test
  asm misc: --no_unaligned_access
  memory RVCT4: ROM 0x0 size 0x180000
  memory RVCT5: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1f000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: .\boot\linker\S32K148_256_flash.sct
  link misc: --info=stack --callgraph --cpu=cortex-m4 --datacompressor off
  group boot
    ./boot/inc/: callbacks.h device_registers.h readme.h startup.h status.h s32_core_cm4.h clock_config.h S32K148.h S32K148_features.h system_S32K148.h
    ./boot/src/: jump_app.s startup.c clock_config.c system_S32K148.c startup_S32K148.S
  group chipset
    ./firmware/inc/: mc_task.h
    ./chipset/inc/: adc_driver.h clock.h clock_manager.h cmp_driver.h crc_driver.h csec_driver.h edma_driver.h eim_driver.h erm_driver.h ewm_driver.h flash_driver.h flash_mx25l6433f_driver.h flexcan_driver.h flexio.h flexio_i2c_driver.h flexio_i2s_driver.h flexio_spi_driver.h flexio_uart_driver.h ftm_common.h ftm_ic_driver.h ftm_mc_driver.h ftm_oc_driver.h ftm_pwm_driver.h ftm_qd_driver.h interrupt_manager.h lpi2c_driver.h lpit_driver.h lpspi_master_driver.h lpspi_shared_function.h lpspi_slave_driver.h lptmr_driver.h lpuart_driver.h mpu_driver.h pdb_driver.h pins_driver.h power_manager.h rtc_driver.h sai_driver.h trgmux_driver.h wdog_driver.h enet_driver.h
    ./chipset/src/adc/: adc_driver.c adc_hw_access.h
    ./chipset/src/clock/S32K1xx/: clock_S32K1xx.c clock_S32K1xx.h pcc_hw_access.h pmc_hw_access.h scg_hw_access.h sim_hw_access.h smc_hw_access.h
    ./chipset/src/cmp/: cmp_hw_access.c cmp_driver.c cmp_hw_access.h
    ./chipset/src/crc/: crc_hw_access.h crc_hw_access.c crc_driver.c
    ./chipset/src/csec/: csec_hw_access.h csec_hw_access.c csec_driver.c
    ./chipset/src/edma/: edma_driver.c edma_hw_access.c edma_hw_access.h edma_irq.c edma_irq.h
    ./chipset/src/eim/: eim_driver.c eim_hw_access.c eim_hw_access.h
    ./chipset/src/erm/: erm_hw_access.h erm_hw_access.c erm_driver.c
    ./chipset/src/ewm/: ewm_hw_access.h ewm_driver.c
    ./chipset/src/flash/: flash_driver.c
    ./chipset/src/flexcan/: flexcan_irq.h flexcan_irq.c flexcan_hw_access.h flexcan_hw_access.c flexcan_driver.c
    ./chipset/src/flexio/: flexio_uart_driver.c flexio_spi_driver.c flexio_i2s_driver.c flexio_i2c_driver.c flexio_common.h flexio_common.c
    ./chipset/src/ftm/: ftm_qd_driver.c ftm_pwm_driver.c ftm_oc_driver.c ftm_mc_driver.c ftm_ic_driver.c ftm_hw_access.h ftm_hw_access.c ftm_common.c
    ./chipset/src/interrupt/: interrupt_manager.c
    ./chipset/src/lpi2c/: lpi2c_irq.h lpi2c_irq.c lpi2c_hw_access.h lpi2c_hw_access.c lpi2c_driver.c
    ./chipset/src/lpit/: lpit_hw_access.h lpit_driver.c
    ./chipset/src/lpspi/: lpspi_slave_driver.c lpspi_shared_function.c lpspi_master_driver.c lpspi_irq.c lpspi_hw_access.h lpspi_hw_access.c
    ./chipset/src/lptmr/: lptmr_hw_access.h lptmr_hw_access.c lptmr_driver.c
    ./chipset/src/lpuart/: lpuart_irq.h lpuart_irq.c lpuart_hw_access.h lpuart_hw_access.c lpuart_driver.c
    ./chipset/src/mpu/: mpu_hw_access.h mpu_hw_access.c mpu_driver.c
    ./chipset/src/pdb/: pdb_hw_access.h pdb_driver.c pdb_hw_access.c
    ./chipset/src/pins/: pins_port_hw_access.h pins_port_hw_access.c pins_gpio_hw_access.h pins_driver.c
    ./chipset/src/power/: power_manager.c
    ./chipset/src/power/S32K1xx/: power_manager_S32K1xx.c power_manager_S32K1xx.h power_rcm_hw_access.h power_scg_hw_access.h power_smc_hw_access.c power_smc_hw_access.h
    ./chipset/src/rtc/: rtc_irq.c rtc_hw_access.h rtc_hw_access.c rtc_driver.c
    ./chipset/src/trgmux/: trgmux_hw_access.h trgmux_hw_access.c trgmux_driver.c
    ./chipset/src/wdog/: wdog_hw_access.h wdog_hw_access.c wdog_driver.c
    ./chipset/src/enet/: enet_driver.c enet_hw_access.c enet_hw_access.h enet_irq.c
  group cmsis
    ./cmsis/: arm_math.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h cmsis_version.h cmsis_compiler.h cmsis_armcc.h cmsis_armclang.h cmsis_gcc.h cmsis_iccarm.h mpu_armv7.h
    ./net/include/arch/: sys_arch.h
  group drivers
    ./drivers/src/: drv_irq.c drv_mem.c drv_spi_legacy.c drv_led.c msdi.c drv_loadswitches.c msdi_s32k14x.c drv_PCA8565.c drv_PAC1921.c drv_dp83tc811s.c
    ./drivers/inc/: drv_mem.h drv_spi_legacy.h drv_led.h msdi.h msdi_cd10x0.h drv_loadswitches.h msdi_s32k14x.h drv_PCA8565.h drv_PAC1921.h drv_dp83tc811s.h
    ./drivers/src/eth/: NXP_SJA1105P_addressResolutionTable.c NXP_SJA1105P_cbs.c NXP_SJA1105P_config.c NXP_SJA1105P_configStream.c NXP_SJA1105P_diagnostics.c NXP_SJA1105P_ethIf.c NXP_SJA1105P_mgmtRoutes.c NXP_SJA1105P_portConfig.c NXP_SJA1105P_ptp.c NXP_SJA1105P_utils.c NXP_SJA1105P_vlan.c
    ./drivers/src/eth/lld/: NXP_SJA1105P_auxiliaryConfigurationUnit.c NXP_SJA1105P_clockGenerationUnit.c NXP_SJA1105P_resetGenerationUnit.c NXP_SJA1105P_sgmii.c NXP_SJA1105P_spi.c NXP_SJA1105P_switchCore.c
    ./drivers/inc/eth/: NXP_SJA1105P_addressResolutionTable.h NXP_SJA1105P_cbs.h NXP_SJA1105P_config.h NXP_SJA1105P_diagnostics.h NXP_SJA1105P_ethIf.h NXP_SJA1105P_mgmtRoutes.h NXP_SJA1105P_portConfig.h NXP_SJA1105P_ptp.h NXP_SJA1105P_utils.h NXP_SJA1105P_vlan.h typedefs.h
    ./drivers/inc/eth/lld/: NXP_SJA1105P_auxiliaryConfigurationUnit.h NXP_SJA1105P_clockGenerationUnit.h NXP_SJA1105P_resetGenerationUnit.h NXP_SJA1105P_sgmii.h NXP_SJA1105P_spi.h NXP_SJA1105P_switchCore.h
    ./drivers/src/icm20948/: DataConverter.c dataconverter.h Icm20948.h icm20948_img.dmp3a.h Icm20948Augmented.c Icm20948Augmented.h Icm20948AuxCompassAkm.c Icm20948AuxCompassAkm.h Icm20948AuxTransport.c Icm20948AuxTransport.h Icm20948DataBaseControl.c Icm20948DataBaseControl.h Icm20948DataBaseDriver.c Icm20948DataBaseDriver.h Icm20948DataConverter.c Icm20948DataConverter.h Icm20948Defs.h Icm20948Dmp3Driver.c Icm20948Dmp3Driver.h Icm20948LoadFirmware.c Icm20948LoadFirmware.h Icm20948MPUFifoControl.c Icm20948MPUFifoControl.h Icm20948SelfTest.c Icm20948SelfTest.h Icm20948Serif.h Icm20948Setup.c Icm20948Setup.h Icm20948Transport.c Icm20948Transport.h InvBool.h InvError.h InvExport.h Message.c Message.h SensorTypes.h
  group firmware
    ./firmware/src/: main.c board.c pin_mux.c coredump_asm.s coredump.c led_task.c mc_task.c swif_task.c lsm_task.c init_task.c pac1921_task.c cd1030.c nvm.c eth_task.c sem_common.c bcm.c udp_task.c lte_uart_task.c version.c shared_mem.c dba_task.c sleep.c odometer_task.c imu.c stat.c imu_dynamics.c err_mgr.c bms_task.c init_msg.c can_messenger_rx.c can_messenger_tx.c bms_can_if.c init_task_desk.c wdt_task.c charger_task.c rm_governor.c rtc_task.c
    ./firmware/inc/: fw_common.h board.h fw_features.h pin_mux.h coredump.h rtc_task.h led_task.h swif_task.h lsm_task.h pac1921_task.h init_task.h cd1030.h batterypack.h stat.h nvm.h eth_task.h sem_common.h bcm.h net_if_cfg.h udp_task.h lte_uart_task.h version.h shared_mem.h dba_task.h sleep.h odometer_task.h imu.h imu_dynamics.h err_mgr.h bms_task.h bms.h init_msg.h can_messenger_rx.h can_messenger_tx.h bms_can_if.h init_task_desk.h fota.h wdt_task.h charger_task.h rm_governor.h mc_task.h
  group util
    ./util/inc/: csec_utils.h debug_console.h devassert.h osif.h ringbuff.h common_utils.h EventRecorderConf.h EventRecorder.h canfd_queue.h
    ./util/src/: csec_utils.c debug_console.c asm_delay.s osif.c ringbuff.c common_utils.c EventRecorder.c canfd_queue.c
  group os
    ./os/RTOS2/RTX/Config/: RTX_Config.h
    ./os/RTOS2/RTX/Include/: rtx_evr.h rtx_os.h
    ./os/RTOS2/RTX/Source/: rtx_core_c.h rtx_core_cm.h rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_lib.c rtx_lib.h rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c
    ./os/RTOS2/RTX/Source/ARM/: irq_cm4f.s
    ./os/RTOS2/Include/: RTE_Components.h cmsis_os2.h
    ./os/RTOS2/Source/: os_systick.c
  group sec
    ./sec/src/: aes.c aes_sw.c
    ./sec/inc/: aes.h aes_sw.h
  group net
    ./net/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ./net/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c sys_arch.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ./net/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ./net/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ./net/include/arch/: cc.h perf.h sys_arch.h
    ./net/include/lwip/: altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip_addr.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h errno.h
    ./net/include/lwip/prot/: ethernet.h iana.h ieee.h
    ./net/include/lwip/priv/: altcp_priv.h api_msg.h mem_priv.h memp_priv.h memp_std.h nd6_priv.h raw_priv.h sockets_priv.h tcp_priv.h tcpip_priv.h
    ./net/include/netif/: bridgeif.h bridgeif_opts.h ieee802154.h lowpan6.h lowpan6_ble.h lowpan6_common.h lowpan6_opts.h slipif.h zepif.h
    ./net/include/netif/ppp/: ccp.h chap_ms.h chap-md5.h chap-new.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
    ./net/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
    ./net/rte/include/: lwipopts_rte.h
    ./net/rte/config/: lwipopts.h
    ./net/netif/: ethernet.c
  group vcu_can_comm_test
    ./vcu_can_comm_test/: vcu_can_comm_test_rx.c vcu_can_comm_test_rx.h vcu_can_comm_test_tx.c vcu_can_comm_test_tx.h Uart.c Uart.h
target VCU_DESK_MODE (6140000::V6.14::ARMCLANG)
  device: S32K148UAxxxLQx NXP
  pack: Keil.S32_SDK_DFP.1.5.0
  cpu: as above
  output: vcu_fw +hex
  BeforeMake: .\build\pre_build.bat
  AfterMake: .\build\post_build.bat
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CPU_S32K148  __ARM_PCS_VFP  __FPU_PRESENT  __TARGET_FPU_VFP USE_FEATURE_VCU_ON_DESK FEATURE_ENET_HAS_RX_CONFIG FEATURE_ENET_HAS_ACCELERATOR FEATURE_ENET_HAS_SLEEP_WAKEUP  FEATURE_ENET_RX_CONFIG_PAYLOAD_LEN_CHECK  FEATURE_ENET_RX_CONFIG_STRIP_CRC_FIELD  FEATURE_ENET_RX_CONFIG_FORWARD_PAUSE_FRAMES  FEATURE_ENET_RX_CONFIG_REMOVE_PADDING FEATURE_ENET_HAS_TX_CONFIG
  c misc: -Wpedantic -mthumb -mno-unaligned-access  -Wno-dollar-in-identifier-extension -mfloat-abi=hard -Wno-covered-switch-default -Wno-padded -Wno-switch-enum -Wno-cast-align -Wno-cast-qual  -Wno-reserved-id-macro -Wno-gnu-zero-variadic-macro-arguments -Wno-empty-translation-unit
  c include: .\boot;.\boot\inc;.\drivers\inc;.\firmware\inc;.\sec\inc;.\test\inc;.\util;.\util\inc;.\util\uzlib;.\util\uzlib\src;.\chipset\inc;.\chipset\src\adc;.\chipset\src\clock\S32K1xx;.\chipset\src\clock;.\chipset\src\cmp;.\chipset\src\crc;.\chipset\src\csec;.\chipset\src\edma;.\chipset\src\eim;.\chipset\src\erm;.\chipset\src\ewm;.\chipset\src\flash;.\chipset\src\flexcan;.\chipset\src\flexio;.\chipset\src\ftm;.\chipset\src\interrupt;.\chipset\src\lpi2c;.\chipset\src\lpit;.\chipset\src\lpspi;.\chipset\src\lptmr;.\chipset\src\lpuart;.\chipset\src\mpu;.\chipset\src\pdb;.\chipset\src\pins;.\chipset\src\power;.\chipset\src\power\S32K1xx;.\chipset\src\rtc;.\chipset\src\trgmux;.\chipset\src\wdog;.\cmsis;.\os\RTOS2\Include;.\os\RTOS2\RTX\Config;.\os\RTOS2\RTX\Include;.\os\RTOS2\RTX\Include1;.\os\RTOS2\RTX\Source;.\drivers\inc\eth;.\drivers\inc\eth\lld;.\os_validation\inc;.\os_validation\src\Config;.\net;.\net\api;.\net\core;.\net\core\ipv4;.\net\core\ipv6;.\net\include;.\net\include\arch;.\net\include\compat\stdc;.\net\include\compat;.\net\include\lwip;.\net\include\lwip\priv;.\net\include\lwip\prot;.\net\include\netif;.\net\include\netif\ppp;.\net\include\netif\ppp\polarssl;.\net\include\posix\sys;.\net\include\posix\sys;.\net\netif\ppp;.\net\netif;.\net\rte\config;.\net\rte\include;.\net\rte;.\drivers\src\icm20948
  asm misc: --no_unaligned_access
  memory RVCT4: ROM 0x0 size 0x180000
  memory RVCT5: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1f000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: .\boot\linker\S32K148_256_flash.sct
  link misc: as above
